Commit message: friction a bit better

File: sumogym/robot_descriptions/simple_robot/dojo.urdf (robot description, URDF)
Before this commit: robot dojo, 1 links, 0 joints
Links:
- link base_link: geometry collision mesh filename=dojo.stl; visual mesh filename=dojo.stl
